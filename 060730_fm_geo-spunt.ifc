Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture]
Time: 2025-09-26T11:37:28
Author: SYRO
Written by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016
Made in: Autodesk Civil 3D 2022 - English Build 13.4.214.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 26 11:37:28 2025 * Host: NO-PF44ARSF * Database: C:\Users\syro\AppData\Local\Temp\ACAIFCTMP/EDM26032\aec_ifc_db * Database version: 5507 * Database creation date: Fri Sep 26 11:37:12 2025 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Fri Sep 26 11:37:23 2025 * Header model: DataRepository.AecIfc_Header * Header model creation date: Fri Sep 26 11:37:23 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5649 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 1
LongName: Spuntmodell GEO
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, Spuntmodell GEO
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingElementProxy (443)
In: Spuntmodell GEO
Name | Senteravstand_fotbolt | Spunt, Type
420 x  | 2.8 m | AZ 13-700-10/10
7 x  | Stag - Type: Ishebeck 40/16; Senteravstand: 2.8 m; Frilengde: ca. 4-7 m; Innboringslengde_berg: minst 3 m; Låselast: 50 kN; Prøvelast: 192 kN
16 x  | Pute - Type: UNP 200; Nivå: kote +0.6
