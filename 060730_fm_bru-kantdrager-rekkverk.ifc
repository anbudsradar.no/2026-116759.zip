Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0], ExchangeRequirement[Structural, SurfaceGeometry], Option [GridExport:Off], Option [Assemblies:Off], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:-1], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Kantdrager og rekkverk.ifc
Time: 2026-03-18T16:01:15
Author: RAMBOLL\ARJN
Organization: Structural Designer
Written by: IFC Parser Version: 3.14.0
Made in: Tekla Structures 2024 Service Pack 6, IFC Export Version: 4.0.0.0 Dec 3 2024

# IfcSite, Undefined
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: BSKINNE, BEAM
In: Undefined
Description: BSKINNE; Material: STEEL/Steel_Undefined
Tekla Common - Class: 6; Phase: 1; Top elevation: +5.401; Bottom elevation: +1.789
Tekla Quantity - Length: 70405.5 mm; Width: 0 mm; Height: 200 mm; Net surface area: 80.548 m2; Area per tons: 85.552 m2; Gross footprint area: 0 m2; Volume: 0.12 m3; Weight: 941.51 kg
BeamBaseQuantities - Length: 70405.5 mm; OuterSurfaceArea: 80.5 m2; NetVolume: 0.1 m3; NetWeight: 941.5 kg
Pset_BeamCommon - Slope: 0.84382 rad; IsExternal: no; LoadBearing: no

# IfcBeam: D20 (296)
In: Undefined
Description: D20
Tekla Common - Phase: 1
Tekla Quantity - Width: 20 mm; Height: 20 mm; Gross footprint area: 0 m2; Volume: 0 m3
BeamBaseQuantities - OuterSurfaceArea: 0 m2; NetVolume: 0 m3
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Name | Material | Class | Top elevation | Bottom elevation | Tekla Quantity, Length (mm) = BeamBaseQuantities, Length (mm) | Net surface area (m2) | Area per tons (m2) | Weight (kg) | NetWeight (kg) | Slope (rad)
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +5.684 | +5.224 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +5.566 | +5.106 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +5.453 | +4.993 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +5.341 | +4.881 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +5.228 | +4.768 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +5.116 | +4.656 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +5.003 | +4.543 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.891 | +4.431 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.778 | +4.318 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.672 | +4.212 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.610 | +4.150 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.549 | +4.089 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.488 | +4.028 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.427 | +3.967 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.366 | +3.906 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.305 | +3.845 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.244 | +3.784 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.183 | +3.723 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.122 | +3.662 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.061 | +3.601 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.015 | +3.555 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.012 | +3.552 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.032 | +3.572 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.039 | +3.579 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.030 | +3.570 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.005 | +3.545 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.964 | +3.504 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.919 | +3.459 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
8 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.872 | +3.412 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.817 | +3.357 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.753 | +3.293 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.678 | +3.218 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.594 | +3.134 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.504 | +3.044 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.415 | +2.955 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.064 | +2.604 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.140 | +2.680 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.216 | +2.756 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.292 | +2.832 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.366 | +2.906 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.436 | +2.976 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.501 | +3.041 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.561 | +3.101 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.616 | +3.156 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.667 | +3.207 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
BEAM | STEEL/Steel_Undefined | 3 | +2.758 | +2.738 | 600 | 0.037 | 28.001 | 1.33 | 1.2 | 0
BEAM | STEEL/Steel_Undefined | 3 | +3.091 | +3.071 | 600 | 0.037 | 28.001 | 1.33 | 1.2 | 0
BEAM | STEEL/Steel_Undefined | 3 | +3.362 | +3.342 | 600 | 0.037 | 28.001 | 1.33 | 1.2 | 0
BEAM | STEEL/Steel_Undefined | 3 | +3.562 | +3.542 | 600 | 0.037 | 28.001 | 1.33 | 1.2 | 0
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.698 | +3.238 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.737 | +3.277 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.800 | +3.340 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.844 | +3.384 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.866 | +3.406 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.850 | +3.390 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.851 | +3.391 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.913 | +3.453 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +3.972 | +3.512 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.034 | +3.574 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.096 | +3.636 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.157 | +3.697 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.219 | +3.759 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.281 | +3.821 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.343 | +3.883 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.405 | +3.945 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.465 | +4.005 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.520 | +4.060 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.582 | +4.122 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.650 | +4.190 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.726 | +4.266 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.808 | +4.348 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.897 | +4.437 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.950 | +4.490 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
4 x 84861000_boltegruppe | STEEL/S355J0 | 520 | +4.849 | +4.389 | 460 | 0.029 | 28.131 | 1.02 | 1 | 1.5708
2 x BEAM | STEEL/Steel_Undefined | 3 | +2.958 | +2.931 | 600 | 0.037 | 28.001 | 1.33 | 1.2 | 0.01095
2 x BEAM | STEEL/Steel_Undefined | 3 | +3.291 | +3.264 | 600 | 0.037 | 28.001 | 1.33 | 1.2 | 0.01095
2 x BEAM | STEEL/Steel_Undefined | 3 | +3.562 | +3.536 | 600 | 0.037 | 28.001 | 1.33 | 1.2 | 0.01095
2 x BEAM | STEEL/Steel_Undefined | 3 | +3.762 | +3.736 | 600 | 0.037 | 28.001 | 1.33 | 1.2 | 0.01095

# IfcBeam: FSKINNE, BEAM
In: Undefined
Description: FSKINNE; Material: STEEL/Steel_Undefined
Tekla Common - Class: 5; Phase: 1; Top elevation: +5.449; Bottom elevation: +3.230
Tekla Quantity - Length: 63291.9 mm; Width: 85.6 mm; Height: 302.8 mm; Net surface area: 60.007 m2; Area per tons: 77.542 m2; Gross footprint area: 0 m2; Volume: 0.099 m3; Weight: 773.87 kg
BeamBaseQuantities - Length: 63291.9 mm; OuterSurfaceArea: 60 m2; NetVolume: 0.1 m3; NetWeight: 773.9 kg
Pset_BeamCommon - Slope: 0.88971 rad; IsExternal: no; LoadBearing: no

# IfcBeam: NUT_M20 (1136)
In: Undefined
Description: NUT_M20; Material: STEEL/S355J0
Tekla Common - Class: 520; Phase: 1
Tekla Quantity - Length: 19 mm; Width: 34.6 mm; Height: 30 mm; Net surface area: 0.004 m2; Area per tons: 30.394 m2; Gross footprint area: 0.001 m2; Volume: 0 m3; Weight: 0.12 kg
BeamBaseQuantities - Length: 19 mm; OuterSurfaceArea: 0 m2; NetVolume: 0 m3; NetWeight: 0.1 kg
Pset_BeamCommon - Slope: 1.5708 rad; IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation
4 x 84861000_boltegruppe | +5.283 | +5.264
4 x 84861000_boltegruppe | +5.667 | +5.648
4 x 84861000_boltegruppe | +5.623 | +5.604
4 x 84861000_boltegruppe | +5.254 | +5.235
4 x 84861000_boltegruppe | +5.165 | +5.146
4 x 84861000_boltegruppe | +5.549 | +5.530
4 x 84861000_boltegruppe | +5.505 | +5.486
4 x 84861000_boltegruppe | +5.136 | +5.117
4 x 84861000_boltegruppe | +5.052 | +5.033
4 x 84861000_boltegruppe | +5.436 | +5.417
4 x 84861000_boltegruppe | +5.392 | +5.373
4 x 84861000_boltegruppe | +5.023 | +5.004
4 x 84861000_boltegruppe | +4.940 | +4.921
4 x 84861000_boltegruppe | +5.324 | +5.305
4 x 84861000_boltegruppe | +5.280 | +5.261
4 x 84861000_boltegruppe | +4.911 | +4.892
4 x 84861000_boltegruppe | +4.827 | +4.808
4 x 84861000_boltegruppe | +5.211 | +5.192
4 x 84861000_boltegruppe | +5.167 | +5.148
4 x 84861000_boltegruppe | +4.798 | +4.779
4 x 84861000_boltegruppe | +4.715 | +4.696
4 x 84861000_boltegruppe | +5.099 | +5.080
4 x 84861000_boltegruppe | +5.055 | +5.036
4 x 84861000_boltegruppe | +4.686 | +4.667
4 x 84861000_boltegruppe | +4.602 | +4.583
4 x 84861000_boltegruppe | +4.986 | +4.967
4 x 84861000_boltegruppe | +4.942 | +4.923
4 x 84861000_boltegruppe | +4.573 | +4.554
4 x 84861000_boltegruppe | +4.490 | +4.471
4 x 84861000_boltegruppe | +4.874 | +4.855
4 x 84861000_boltegruppe | +4.830 | +4.811
4 x 84861000_boltegruppe | +4.461 | +4.442
4 x 84861000_boltegruppe | +4.377 | +4.358
4 x 84861000_boltegruppe | +4.761 | +4.742
4 x 84861000_boltegruppe | +4.717 | +4.698
4 x 84861000_boltegruppe | +4.348 | +4.329
4 x 84861000_boltegruppe | +4.271 | +4.252
4 x 84861000_boltegruppe | +4.655 | +4.636
4 x 84861000_boltegruppe | +4.611 | +4.592
4 x 84861000_boltegruppe | +4.242 | +4.223
4 x 84861000_boltegruppe | +4.209 | +4.190
4 x 84861000_boltegruppe | +4.593 | +4.574
8 x 84861000_boltegruppe | +4.549 | +4.530
4 x 84861000_boltegruppe | +4.180 | +4.161
4 x 84861000_boltegruppe | +4.148 | +4.129
4 x 84861000_boltegruppe | +4.532 | +4.513
4 x 84861000_boltegruppe | +4.488 | +4.469
8 x 84861000_boltegruppe | +4.119 | +4.100
4 x 84861000_boltegruppe | +4.087 | +4.068
4 x 84861000_boltegruppe | +4.471 | +4.452
4 x 84861000_boltegruppe | +4.427 | +4.408
4 x 84861000_boltegruppe | +4.058 | +4.039
4 x 84861000_boltegruppe | +4.026 | +4.007
4 x 84861000_boltegruppe | +4.410 | +4.391
4 x 84861000_boltegruppe | +4.366 | +4.347
4 x 84861000_boltegruppe | +3.997 | +3.978
4 x 84861000_boltegruppe | +3.965 | +3.946
4 x 84861000_boltegruppe | +4.349 | +4.330
4 x 84861000_boltegruppe | +4.305 | +4.286
4 x 84861000_boltegruppe | +3.936 | +3.917
4 x 84861000_boltegruppe | +3.904 | +3.885
4 x 84861000_boltegruppe | +4.288 | +4.269
4 x 84861000_boltegruppe | +4.244 | +4.225
4 x 84861000_boltegruppe | +3.875 | +3.856
4 x 84861000_boltegruppe | +3.843 | +3.824
4 x 84861000_boltegruppe | +4.227 | +4.208
4 x 84861000_boltegruppe | +4.183 | +4.164
4 x 84861000_boltegruppe | +3.814 | +3.795
4 x 84861000_boltegruppe | +3.782 | +3.763
4 x 84861000_boltegruppe | +4.166 | +4.147
4 x 84861000_boltegruppe | +4.122 | +4.103
4 x 84861000_boltegruppe | +3.753 | +3.734
4 x 84861000_boltegruppe | +3.721 | +3.702
4 x 84861000_boltegruppe | +4.105 | +4.086
4 x 84861000_boltegruppe | +4.061 | +4.042
8 x 84861000_boltegruppe | +3.692 | +3.673
4 x 84861000_boltegruppe | +3.660 | +3.641
4 x 84861000_boltegruppe | +4.044 | +4.025
4 x 84861000_boltegruppe | +4.000 | +3.981
8 x 84861000_boltegruppe | +3.631 | +3.612
4 x 84861000_boltegruppe | +3.614 | +3.595
4 x 84861000_boltegruppe | +3.998 | +3.979
4 x 84861000_boltegruppe | +3.954 | +3.935
4 x 84861000_boltegruppe | +3.585 | +3.566
4 x 84861000_boltegruppe | +3.611 | +3.592
4 x 84861000_boltegruppe | +3.995 | +3.976
4 x 84861000_boltegruppe | +3.951 | +3.932
4 x 84861000_boltegruppe | +3.582 | +3.563
4 x 84861000_boltegruppe | +4.015 | +3.996
4 x 84861000_boltegruppe | +3.971 | +3.952
4 x 84861000_boltegruppe | +3.602 | +3.583
4 x 84861000_boltegruppe | +3.638 | +3.619
4 x 84861000_boltegruppe | +4.022 | +4.003
4 x 84861000_boltegruppe | +3.978 | +3.959
4 x 84861000_boltegruppe | +3.609 | +3.590
4 x 84861000_boltegruppe | +3.629 | +3.610
4 x 84861000_boltegruppe | +4.013 | +3.994
4 x 84861000_boltegruppe | +3.969 | +3.950
4 x 84861000_boltegruppe | +3.600 | +3.581
8 x 84861000_boltegruppe | +3.604 | +3.585
4 x 84861000_boltegruppe | +3.988 | +3.969
4 x 84861000_boltegruppe | +3.944 | +3.925
4 x 84861000_boltegruppe | +3.575 | +3.556
4 x 84861000_boltegruppe | +3.563 | +3.544
4 x 84861000_boltegruppe | +3.947 | +3.928
4 x 84861000_boltegruppe | +3.903 | +3.884
4 x 84861000_boltegruppe | +3.534 | +3.515
4 x 84861000_boltegruppe | +3.518 | +3.499
4 x 84861000_boltegruppe | +3.901 | +3.882
4 x 84861000_boltegruppe | +3.857 | +3.838
4 x 84861000_boltegruppe | +3.489 | +3.470
8 x 84861000_boltegruppe | +3.471 | +3.452
8 x 84861000_boltegruppe | +3.855 | +3.836
8 x 84861000_boltegruppe | +3.811 | +3.792
8 x 84861000_boltegruppe | +3.442 | +3.423
4 x 84861000_boltegruppe | +3.416 | +3.397
4 x 84861000_boltegruppe | +3.800 | +3.781
8 x 84861000_boltegruppe | +3.756 | +3.737
4 x 84861000_boltegruppe | +3.387 | +3.368
4 x 84861000_boltegruppe | +3.352 | +3.333
4 x 84861000_boltegruppe | +3.736 | +3.717
4 x 84861000_boltegruppe | +3.323 | +3.304
4 x 84861000_boltegruppe | +3.277 | +3.258
4 x 84861000_boltegruppe | +3.661 | +3.642
4 x 84861000_boltegruppe | +3.617 | +3.598
4 x 84861000_boltegruppe | +3.248 | +3.229
4 x 84861000_boltegruppe | +3.193 | +3.174
4 x 84861000_boltegruppe | +3.576 | +3.557
4 x 84861000_boltegruppe | +3.532 | +3.513
4 x 84861000_boltegruppe | +3.164 | +3.145
4 x 84861000_boltegruppe | +3.103 | +3.084
4 x 84861000_boltegruppe | +3.487 | +3.468
8 x 84861000_boltegruppe | +3.443 | +3.424
4 x 84861000_boltegruppe | +3.074 | +3.055
4 x 84861000_boltegruppe | +3.014 | +2.995
4 x 84861000_boltegruppe | +3.398 | +3.379
4 x 84861000_boltegruppe | +3.354 | +3.335
4 x 84861000_boltegruppe | +2.985 | +2.966
4 x 84861000_boltegruppe | +2.663 | +2.644
4 x 84861000_boltegruppe | +3.047 | +3.028
4 x 84861000_boltegruppe | +3.003 | +2.984
4 x 84861000_boltegruppe | +2.634 | +2.615
4 x 84861000_boltegruppe | +2.739 | +2.720
4 x 84861000_boltegruppe | +3.123 | +3.104
4 x 84861000_boltegruppe | +3.079 | +3.060
4 x 84861000_boltegruppe | +2.710 | +2.691
4 x 84861000_boltegruppe | +2.815 | +2.796
4 x 84861000_boltegruppe | +3.199 | +3.180
4 x 84861000_boltegruppe | +3.155 | +3.136
4 x 84861000_boltegruppe | +2.786 | +2.767
4 x 84861000_boltegruppe | +2.891 | +2.872
4 x 84861000_boltegruppe | +3.275 | +3.256
4 x 84861000_boltegruppe | +3.231 | +3.212
4 x 84861000_boltegruppe | +2.862 | +2.843
4 x 84861000_boltegruppe | +2.965 | +2.946
4 x 84861000_boltegruppe | +3.349 | +3.330
4 x 84861000_boltegruppe | +3.305 | +3.286
4 x 84861000_boltegruppe | +2.936 | +2.917
4 x 84861000_boltegruppe | +3.035 | +3.016
4 x 84861000_boltegruppe | +3.419 | +3.400
4 x 84861000_boltegruppe | +3.375 | +3.356
4 x 84861000_boltegruppe | +3.006 | +2.987
4 x 84861000_boltegruppe | +3.100 | +3.081
4 x 84861000_boltegruppe | +3.484 | +3.465
4 x 84861000_boltegruppe | +3.440 | +3.421
4 x 84861000_boltegruppe | +3.071 | +3.052
4 x 84861000_boltegruppe | +3.160 | +3.141
4 x 84861000_boltegruppe | +3.544 | +3.525
4 x 84861000_boltegruppe | +3.500 | +3.481
4 x 84861000_boltegruppe | +3.131 | +3.112
4 x 84861000_boltegruppe | +3.215 | +3.196
4 x 84861000_boltegruppe | +3.599 | +3.580
4 x 84861000_boltegruppe | +3.555 | +3.536
4 x 84861000_boltegruppe | +3.186 | +3.167
4 x 84861000_boltegruppe | +3.266 | +3.247
4 x 84861000_boltegruppe | +3.650 | +3.631
4 x 84861000_boltegruppe | +3.606 | +3.587
4 x 84861000_boltegruppe | +3.237 | +3.218
4 x 84861000_boltegruppe | +3.297 | +3.278
4 x 84861000_boltegruppe | +3.681 | +3.662
4 x 84861000_boltegruppe | +3.637 | +3.618
4 x 84861000_boltegruppe | +3.268 | +3.249
4 x 84861000_boltegruppe | +3.336 | +3.317
4 x 84861000_boltegruppe | +3.720 | +3.701
4 x 84861000_boltegruppe | +3.676 | +3.657
4 x 84861000_boltegruppe | +3.307 | +3.288
4 x 84861000_boltegruppe | +3.399 | +3.380
8 x 84861000_boltegruppe | +3.783 | +3.764
4 x 84861000_boltegruppe | +3.739 | +3.720
4 x 84861000_boltegruppe | +3.370 | +3.351
4 x 84861000_boltegruppe | +3.827 | +3.808
4 x 84861000_boltegruppe | +3.414 | +3.395
4 x 84861000_boltegruppe | +3.465 | +3.446
4 x 84861000_boltegruppe | +3.849 | +3.830
4 x 84861000_boltegruppe | +3.805 | +3.786
4 x 84861000_boltegruppe | +3.436 | +3.417
4 x 84861000_boltegruppe | +3.449 | +3.430
4 x 84861000_boltegruppe | +3.833 | +3.814
8 x 84861000_boltegruppe | +3.789 | +3.770
4 x 84861000_boltegruppe | +3.420 | +3.401
4 x 84861000_boltegruppe | +3.450 | +3.431
4 x 84861000_boltegruppe | +3.834 | +3.815
4 x 84861000_boltegruppe | +3.790 | +3.771
4 x 84861000_boltegruppe | +3.421 | +3.402
4 x 84861000_boltegruppe | +3.512 | +3.493
4 x 84861000_boltegruppe | +3.896 | +3.877
4 x 84861000_boltegruppe | +3.852 | +3.833
4 x 84861000_boltegruppe | +3.483 | +3.464
4 x 84861000_boltegruppe | +3.571 | +3.552
4 x 84861000_boltegruppe | +3.955 | +3.936
4 x 84861000_boltegruppe | +3.911 | +3.892
4 x 84861000_boltegruppe | +3.542 | +3.523
4 x 84861000_boltegruppe | +3.633 | +3.614
4 x 84861000_boltegruppe | +4.017 | +3.998
4 x 84861000_boltegruppe | +3.973 | +3.954
4 x 84861000_boltegruppe | +3.695 | +3.676
4 x 84861000_boltegruppe | +4.079 | +4.060
8 x 84861000_boltegruppe | +4.035 | +4.016
4 x 84861000_boltegruppe | +3.666 | +3.647
4 x 84861000_boltegruppe | +4.140 | +4.121
4 x 84861000_boltegruppe | +4.096 | +4.077
4 x 84861000_boltegruppe | +3.727 | +3.708
4 x 84861000_boltegruppe | +3.818 | +3.799
4 x 84861000_boltegruppe | +4.202 | +4.183
4 x 84861000_boltegruppe | +4.158 | +4.139
4 x 84861000_boltegruppe | +3.880 | +3.861
4 x 84861000_boltegruppe | +4.264 | +4.245
8 x 84861000_boltegruppe | +4.220 | +4.201
4 x 84861000_boltegruppe | +3.851 | +3.832
4 x 84861000_boltegruppe | +3.942 | +3.923
4 x 84861000_boltegruppe | +4.326 | +4.307
4 x 84861000_boltegruppe | +4.282 | +4.263
4 x 84861000_boltegruppe | +3.913 | +3.894
4 x 84861000_boltegruppe | +4.004 | +3.985
4 x 84861000_boltegruppe | +4.388 | +4.369
4 x 84861000_boltegruppe | +4.344 | +4.325
4 x 84861000_boltegruppe | +3.975 | +3.956
4 x 84861000_boltegruppe | +4.064 | +4.045
8 x 84861000_boltegruppe | +4.448 | +4.429
4 x 84861000_boltegruppe | +4.404 | +4.385
4 x 84861000_boltegruppe | +4.503 | +4.484
4 x 84861000_boltegruppe | +4.459 | +4.440
4 x 84861000_boltegruppe | +4.090 | +4.071
4 x 84861000_boltegruppe | +4.181 | +4.162
4 x 84861000_boltegruppe | +4.565 | +4.546
4 x 84861000_boltegruppe | +4.521 | +4.502
4 x 84861000_boltegruppe | +4.152 | +4.133
4 x 84861000_boltegruppe | +4.249 | +4.230
4 x 84861000_boltegruppe | +4.633 | +4.614
4 x 84861000_boltegruppe | +4.589 | +4.570
4 x 84861000_boltegruppe | +4.325 | +4.306
4 x 84861000_boltegruppe | +4.709 | +4.690
4 x 84861000_boltegruppe | +4.665 | +4.646
4 x 84861000_boltegruppe | +4.296 | +4.277
4 x 84861000_boltegruppe | +4.407 | +4.388
4 x 84861000_boltegruppe | +4.791 | +4.772
4 x 84861000_boltegruppe | +4.747 | +4.728
4 x 84861000_boltegruppe | +4.378 | +4.359
4 x 84861000_boltegruppe | +4.496 | +4.477
4 x 84861000_boltegruppe | +4.880 | +4.861
4 x 84861000_boltegruppe | +4.836 | +4.817
4 x 84861000_boltegruppe | +4.467 | +4.448
4 x 84861000_boltegruppe | +4.933 | +4.914
4 x 84861000_boltegruppe | +4.889 | +4.870
4 x 84861000_boltegruppe | +4.520 | +4.501
4 x 84861000_boltegruppe | +4.832 | +4.813
4 x 84861000_boltegruppe | +4.788 | +4.769
4 x 84861000_boltegruppe | +4.419 | +4.400

# IfcBeam: PRMD200*200-0.2*0.2 (71)
In: Undefined
Description: PRMD200*200-0.2*0.2; Material: CONCRETE/Concrete_Undefined
Tekla Common - Class: 4; Phase: 1
Tekla Quantity - Length: 200 mm; Width: 200 mm; Height: 200 mm; Net surface area: 0.13 m2; Area per tons: 20.216 m2; Gross footprint area: 0.04 m2; Volume: 0.003 m3; Weight: 6.41 kg
BeamBaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.1 m2; NetVolume: 0 m3; NetWeight: 6.4 kg
Pset_BeamCommon - Slope: 1.5708 rad; IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation
S84861000_boltegruppe | +5.823 | +5.623
S84861000_boltegruppe | +5.705 | +5.505
S84861000_boltegruppe | +5.592 | +5.392
S84861000_boltegruppe | +5.480 | +5.280
S84861000_boltegruppe | +5.367 | +5.167
S84861000_boltegruppe | +5.255 | +5.055
S84861000_boltegruppe | +5.142 | +4.942
S84861000_boltegruppe | +5.030 | +4.830
S84861000_boltegruppe | +4.917 | +4.717
S84861000_boltegruppe | +4.811 | +4.611
S84861000_boltegruppe | +4.749 | +4.549
S84861000_boltegruppe | +4.688 | +4.488
S84861000_boltegruppe | +4.627 | +4.427
S84861000_boltegruppe | +4.566 | +4.366
S84861000_boltegruppe | +4.505 | +4.305
S84861000_boltegruppe | +4.444 | +4.244
S84861000_boltegruppe | +4.383 | +4.183
S84861000_boltegruppe | +4.322 | +4.122
S84861000_boltegruppe | +4.261 | +4.061
S84861000_boltegruppe | +4.200 | +4.000
S84861000_boltegruppe | +4.154 | +3.954
S84861000_boltegruppe | +4.151 | +3.951
S84861000_boltegruppe | +4.171 | +3.971
S84861000_boltegruppe | +4.178 | +3.978
S84861000_boltegruppe | +4.169 | +3.969
S84861000_boltegruppe | +4.144 | +3.944
S84861000_boltegruppe | +4.103 | +3.903
S84861000_boltegruppe | +4.057 | +3.857
2 x S84861000_boltegruppe | +4.011 | +3.811
S84861000_boltegruppe | +3.956 | +3.756
S84861000_boltegruppe | +3.892 | +3.692
S84861000_boltegruppe | +3.817 | +3.617
S84861000_boltegruppe | +3.732 | +3.532
S84861000_boltegruppe | +3.643 | +3.443
S84861000_boltegruppe | +3.554 | +3.354
S84861000_boltegruppe | +3.203 | +3.003
S84861000_boltegruppe | +3.279 | +3.079
S84861000_boltegruppe | +3.355 | +3.155
S84861000_boltegruppe | +3.431 | +3.231
S84861000_boltegruppe | +3.505 | +3.305
S84861000_boltegruppe | +3.575 | +3.375
S84861000_boltegruppe | +3.640 | +3.440
S84861000_boltegruppe | +3.700 | +3.500
S84861000_boltegruppe | +3.755 | +3.555
S84861000_boltegruppe | +3.806 | +3.606
S84861000_boltegruppe | +3.837 | +3.637
S84861000_boltegruppe | +3.876 | +3.676
S84861000_boltegruppe | +3.939 | +3.739
S84861000_boltegruppe | +3.983 | +3.783
S84861000_boltegruppe | +4.005 | +3.805
S84861000_boltegruppe | +3.989 | +3.789
S84861000_boltegruppe | +3.990 | +3.790
S84861000_boltegruppe | +4.052 | +3.852
S84861000_boltegruppe | +4.111 | +3.911
S84861000_boltegruppe | +4.173 | +3.973
S84861000_boltegruppe | +4.235 | +4.035
S84861000_boltegruppe | +4.296 | +4.096
S84861000_boltegruppe | +4.358 | +4.158
S84861000_boltegruppe | +4.420 | +4.220
S84861000_boltegruppe | +4.482 | +4.282
S84861000_boltegruppe | +4.544 | +4.344
S84861000_boltegruppe | +4.604 | +4.404
S84861000_boltegruppe | +4.659 | +4.459
S84861000_boltegruppe | +4.721 | +4.521
S84861000_boltegruppe | +4.789 | +4.589
S84861000_boltegruppe | +4.865 | +4.665
S84861000_boltegruppe | +4.947 | +4.747
S84861000_boltegruppe | +5.036 | +4.836
S84861000_boltegruppe | +5.089 | +4.889
S84861000_boltegruppe | +4.988 | +4.788

# IfcBeam: RHS60*40*3 (4)
In: Undefined
Description: RHS60*40*3; Material: STEEL/Steel_Undefined
Tekla Common - Class: 4; Phase: 1
Tekla Quantity - Width: 40 mm; Height: 60 mm; Gross footprint area: 0.038 m2; Volume: 0 m3
BeamBaseQuantities - OuterSurfaceArea: 0.1 m2; NetVolume: 0 m3; NetWeight: 2.8 kg
Pset_BeamCommon - Slope: 0 rad; IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation | Tekla Quantity, Length (mm) = BeamBaseQuantities, Length (mm) | Net surface area (m2) | Area per tons (m2) | Weight (kg)
BEAM | +5.813 | +5.773 | 626.5 | 0.125 | 44.912 | 2.77
BEAM | +3.481 | +3.441 | 631.9 | 0.126 | 44.91 | 2.8
BEAM | +3.766 | +3.726 | 627 | 0.125 | 44.912 | 2.78
BEAM | +4.890 | +4.850 | 630.3 | 0.125 | 44.91 | 2.78

# IfcBeam: SIGMA (12)
In: Undefined
Description: SIGMA; Material: STEEL/Steel_Undefined
Tekla Common - Class: 3; Phase: 1
Tekla Quantity - Length: 1200 mm; Width: 100 mm; Height: 55 mm; Net surface area: 0.578 m2; Area per tons: 0 m2; Gross footprint area: 0.001 m2; Volume: 0.001 m3; Weight: 9.18 kg
BeamBaseQuantities - Length: 1200 mm; OuterSurfaceArea: 0 m2; NetVolume: 0 m3; NetWeight: 9.2 kg
Pset_BeamCommon - Slope: 1.5708 rad; IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation
BEAM | +4.183 | +2.983
BEAM | +2.019 | +0.819
BEAM | +4.801 | +3.601
BEAM | +5.029 | +3.829
BEAM | +5.167 | +3.967
BEAM | +3.442 | +2.242
BEAM | +3.365 | +2.165
BEAM | +3.288 | +2.088
BEAM | +3.105 | +1.905
BEAM | +2.826 | +1.626
BEAM | +2.547 | +1.347
BEAM | +2.269 | +1.069

# IfcBeam: U120*60*5 (6)
In: Undefined
Description: U120*60*5; Material: STEEL/Steel_Undefined
Tekla Common - Class: 4; Phase: 1
Tekla Quantity - Width: 60 mm; Height: 120 mm; Gross footprint area: 0 m2
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation | Tekla Quantity, Length (mm) = BeamBaseQuantities, Length (mm) | Net surface area (m2) | Area per tons (m2) | Volume (m3) | Weight (kg) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg) | Slope (rad)
BEAM | +6.664 | +5.710 | 1209.8 | 0.581 | 52.206 | 0.001 | 11.13 | 0.6 | 0 | 11.1 | 0.05628
BEAM | +4.386 | +3.378 | 1252.8 | 0.6 | 52.206 | 0.001 | 11.5 | 0.6 | 0 | 11.5 | 0.04466
BEAM | +6.655 | +4.326 | 67626.6 | 31.787 | 52.067 | 0.078 | 610.5 | 31.8 | 0.1 | 610.5 | 0.04463
BEAM | +4.668 | +3.663 | 1250.6 | 0.6 | 52.206 | 0.001 | 11.48 | 0.6 | 0 | 11.5 | 0.0395
BEAM | +5.819 | +4.787 | 1268.8 | 0.608 | 52.206 | 0.001 | 11.64 | 0.6 | 0 | 11.6 | 0.08354
BEAM | +5.925 | +4.608 | 47897.4 | 22.514 | 52.067 | 0.055 | 432.4 | 22.5 | 0.1 | 432.4 | 0.08176

# IfcBeam: U60*40*3 (59)
In: Undefined
Description: U60*40*3; Material: STEEL/Steel_Undefined
Tekla Common - Class: 3; Phase: 1
Tekla Quantity - Width: 40 mm; Height: 60 mm
BeamBaseQuantities - NetVolume: 0 m3
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation | Tekla Quantity, Length (mm) = BeamBaseQuantities, Length (mm) | Net surface area (m2) | Area per tons (m2) | Gross footprint area (m2) | Volume (m3) | Weight (kg) | OuterSurfaceArea (m2) | NetWeight (kg) | Slope (rad)
BEAM | +4.956 | +4.804 | 1994.6 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.05682
BEAM | +4.844 | +4.698 | 1982.2 | 0.544 | 86.956 | 0 | 0.001 | 6.26 | 0.5 | 6.4 | 0.04426
BEAM | +4.737 | +4.636 | 1992.5 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.02735
BEAM | +4.676 | +4.575 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.0314
BEAM | +4.188 | +4.087 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03017
BEAM | +4.127 | +4.041 | 1951.2 | 0.535 | 86.958 | 0 | 0.001 | 6.16 | 0.5 | 6.2 | 0.01448
BEAM | +4.081 | +4.034 | 1928.2 | 0.529 | 86.96 | 0 | 0.001 | 6.08 | 0.5 | 6.2 | 0.00723
BEAM | +4.098 | +4.037 | 1925.2 | 0.528 | 86.959 | 0 | 0.001 | 6.08 | 0.5 | 6.2 | 0.00931
BEAM | +4.105 | +4.058 | 1926.6 | 0.529 | 86.959 | 0.022 | 0.001 | 6.08 | 0.5 | 6.2 | 0.00067
BEAM | +4.105 | +4.056 | 1926.6 | 0.529 | 86.959 | 0.007 | 0.001 | 6.08 | 0.5 | 6.2 | 0.00838
BEAM | +4.096 | +4.031 | 1927.1 | 0.529 | 86.959 | 0 | 0.001 | 6.08 | 0.5 | 6.2 | 0.0173
BEAM | +4.071 | +3.990 | 1938.2 | 0.532 | 86.958 | 0 | 0.001 | 6.12 | 0.5 | 6.2 | 0.0227
BEAM | +4.030 | +3.944 | 1994.6 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.02284
BEAM | +3.984 | +3.898 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.02376
BEAM | +3.938 | +3.843 | 1994.6 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.0286
BEAM | +3.883 | +3.778 | 1993.6 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03358
BEAM | +3.818 | +3.704 | 1992.5 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03939
BEAM | +3.744 | +3.619 | 1991.4 | 0.546 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.04374
BEAM | +3.659 | +3.530 | 1990.2 | 0.546 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.04485
BEAM | +3.570 | +3.441 | 1989 | 0.546 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.04463
BEAM | +5.750 | +5.592 | 2098.2 | 0.576 | 86.948 | 0 | 0.001 | 6.62 | 0.6 | 6.6 | 0.05628
BEAM | +5.631 | +5.479 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.05628
BEAM | +5.519 | +5.367 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.05628
BEAM | +5.406 | +5.254 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.05628
BEAM | +5.294 | +5.142 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.05628
BEAM | +5.181 | +5.029 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.05628
BEAM | +5.069 | +4.917 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.05628
BEAM | +4.615 | +4.514 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03052
BEAM | +4.554 | +4.453 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03052
BEAM | +4.493 | +4.392 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.0305
BEAM | +4.432 | +4.331 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03046
BEAM | +4.371 | +4.270 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03046
BEAM | +4.310 | +4.209 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03046
BEAM | +4.249 | +4.148 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03046
BEAM | +3.865 | +3.763 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.02772
BEAM | +3.909 | +3.825 | 1995.7 | 0.548 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.01927
BEAM | +3.931 | +3.869 | 1892.6 | 0.519 | 86.96 | 0.007 | 0.001 | 5.97 | 0.5 | 6 | 0.00055
BEAM | +3.931 | +3.876 | 1859.1 | 0.51 | 86.964 | 0 | 0.001 | 5.87 | 0.5 | 6 | 0.00805
BEAM | +3.917 | +3.873 | 1929.5 | 0.529 | 86.959 | 0 | 0.001 | 6.08 | 0.5 | 6.2 | 0.00589
BEAM | +3.938 | +3.877 | 1939.7 | 0.532 | 86.959 | 0 | 0.001 | 6.12 | 0.5 | 6.2 | 0.01534
BEAM | +3.979 | +3.898 | 1940.1 | 0.532 | 86.959 | 0 | 0.001 | 6.12 | 0.5 | 6.2 | 0.02605
BEAM | +4.038 | +3.939 | 1941.3 | 0.533 | 86.958 | 0 | 0.001 | 6.12 | 0.5 | 6.2 | 0.03202
BEAM | +4.099 | +3.998 | 1940.1 | 0.532 | 86.958 | 0 | 0.001 | 6.12 | 0.5 | 6.2 | 0.03131
BEAM | +4.161 | +4.060 | 1988.5 | 0.546 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03092
BEAM | +4.223 | +4.121 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03092
BEAM | +4.285 | +4.183 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03092
BEAM | +4.470 | +4.369 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03104
BEAM | +4.531 | +4.430 | 1995.5 | 0.548 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.0287
BEAM | +4.585 | +4.491 | 1979.4 | 0.543 | 86.956 | 0 | 0.001 | 6.26 | 0.5 | 6.2 | 0.02784
BEAM | +4.647 | +4.545 | 1991.1 | 0.546 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03275
BEAM | +4.716 | +4.608 | 1987.6 | 0.545 | 86.955 | 0 | 0.001 | 6.27 | 0.5 | 6.4 | 0.03553
BEAM | +4.791 | +4.676 | 1984.1 | 0.544 | 86.955 | 0 | 0.001 | 6.26 | 0.5 | 6.4 | 0.03942
BEAM | +4.873 | +4.751 | 1980.3 | 0.543 | 86.956 | 0 | 0.001 | 6.26 | 0.5 | 6.2 | 0.0426
BEAM | +4.963 | +4.833 | 1980.5 | 0.543 | 86.956 | 0 | 0.001 | 6.26 | 0.5 | 6.2 | 0.04746
BEAM | +5.017 | +4.923 | 1735.5 | 0.476 | 86.972 | 0.003 | 0.001 | 5.48 | 0.5 | 5.5 | 0.01351
BEAM | +5.017 | +4.875 | 1685.1 | 0.463 | 86.977 | 0 | 0.001 | 5.32 | 0.5 | 5.3 | 0.08263
BEAM | +3.803 | +3.723 | 1057.7 | 0.291 | 87.068 | 0 | 0 | 3.34 | 0.3 | 3.3 | 0.03735
BEAM | +4.347 | +4.245 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03092
BEAM | +4.409 | +4.307 | 1994.9 | 0.547 | 86.955 | 0 | 0.001 | 6.29 | 0.5 | 6.4 | 0.03092

# IfcBuildingElementProxy: _0TErCA93HUiS-y8LqrhQ_A_0, CONCRETE ITEM
In: Undefined
Description: _0TErCA93HUiS-y8LqrhQ_A_0; Material: CONCRETE/Concrete_Undefined
Tekla Common - Class: 107; Phase: 1; Top elevation: +3.743; Bottom elevation: +1.687
Tekla Quantity - Length: 12320.1 mm; Width: 12219.7 mm; Height: 2055.9 mm; Net surface area: 98.171 m2; Area per tons: 3.013 m2; Gross footprint area: 0 m2; Volume: 13.578 m3; Weight: 32587.3 kg
Pours - Pour Comment: WIP : railing; Pour Area: 98.2 m2; Pour Area PGZ: 38.6 m2; Pour Area NGZ: 39.2 m2; Pour Area PGX: 0.9 m2; Pour Area NXG: 0.9 m2; Pour Area PGY: 8.4 m2; Pour Area NGY: 7.3 m2; Pour Content Type: PART; Pour Material: Concrete_Undefined; Pour Top Level: +3.743; Pour Bottom Level: +1.687; Pour Volume: 13.578 m3; Pour Weight: 32587.3 kg; Pour Weight Net: 32587.3 kg; Pour Break Comment: WIP : railing

# IfcBuildingElementProxy: _0TErCA93HUiS-y8LqrhQ_A_1, CONCRETE ITEM
In: Undefined
Description: _0TErCA93HUiS-y8LqrhQ_A_1; Material: CONCRETE/Concrete_Undefined
Tekla Common - Class: 107; Phase: 1; Top elevation: +4.109; Bottom elevation: +2.490
Tekla Quantity - Length: 9143.2 mm; Width: 19738.1 mm; Height: 1619 mm; Net surface area: 136.955 m2; Area per tons: 2.969 m2; Gross footprint area: 0 m2; Volume: 19.22 m3; Weight: 46128.8 kg
Pours - Pour Comment: WIP : railing; Pour Area: 137 m2; Pour Area PGZ: 54.5 m2; Pour Area NGZ: 55.2 m2; Pour Area PGX: 12 m2; Pour Area NXG: 11.2 m2; Pour Area PGY: 1.7 m2; Pour Area NGY: 0.7 m2; Pour Content Type: PART; Pour Material: Concrete_Undefined; Pour Top Level: +4.109; Pour Bottom Level: +2.490; Pour Volume: 19.22 m3; Pour Weight: 46128.7 kg; Pour Weight Net: 46128.7 kg; Pour Break Comment: WIP : railing

# IfcBuildingElementProxy: _7kT4GTjmEE-SDmgukMiv0w_0, CONCRETE ITEM
In: Undefined
Description: _7kT4GTjmEE-SDmgukMiv0w_0; Material: CONCRETE/Concrete_Undefined
Tekla Common - Class: 107; Phase: 1; Top elevation: +3.940; Bottom elevation: +2.052
Tekla Quantity - Length: 18740 mm; Width: 11794.5 mm; Height: 1888.2 mm; Net surface area: 133.232 m2; Area per tons: 2.994 m2; Gross footprint area: 0 m2; Volume: 18.544 m3; Weight: 44504.6 kg
Pours - Pour Area: 133.2 m2; Pour Area PGZ: 52.5 m2; Pour Area NGZ: 53.6 m2; Pour Area PGX: 0.9 m2; Pour Area NXG: 0.9 m2; Pour Area PGY: 11.3 m2; Pour Area NGY: 12.1 m2; Pour Content Type: PART; Pour Material: Concrete_Undefined; Pour Top Level: +3.940; Pour Bottom Level: +2.052; Pour Volume: 18.544 m3; Pour Weight: 44504.6 kg; Pour Weight Net: 44504.6 kg

# IfcBuildingElementProxy: _CtgwbqtEV0a2IsrgZGj6QQ_0, SVV Betong
In: Undefined
Description: _CtgwbqtEV0a2IsrgZGj6QQ_0; Material: CONCRETE/Concrete_Undefined
Tekla Common - Class: 20; Phase: 1; Top elevation: +7.497; Bottom elevation: +5.506
Tekla Quantity - Length: 16099.2 mm; Width: 14100.5 mm; Height: 1990.8 mm; Net surface area: 32.613 m2; Area per tons: 4.438 m2; Gross footprint area: 0 m2; Volume: 3.062 m3; Weight: 7349.27 kg
Pours - Pour Comment: Railing updated; Pour Area: 32.6 m2; Pour Area PGZ: 3.9 m2; Pour Area NGZ: 8.4 m2; Pour Area PGX: 1.1 m2; Pour Area NXG: 1.2 m2; Pour Area PGY: 6.4 m2; Pour Area NGY: 6.7 m2; Pour Content Type: PART; Pour Material: Concrete_Undefined; Pour Top Level: +7.497; Pour Bottom Level: +5.506; Pour Volume: 3.062 m3; Pour Weight: 7349.3 kg; Pour Weight Net: 7349.3 kg; Pour Break Comment: Railing updated

# IfcBuildingElementProxy: _HvUeshz3xEiAznSJevQznw_0, CONCRETE ITEM
In: Undefined
Description: _HvUeshz3xEiAznSJevQznw_0; Material: CONCRETE/Concrete_Undefined
Tekla Common - Class: 107; Phase: 1; Top elevation: +4.309; Bottom elevation: +2.670
Tekla Quantity - Length: 18937.1 mm; Width: 13657 mm; Height: 1639 mm; Net surface area: 145.413 m2; Area per tons: 3.007 m2; Gross footprint area: 0 m2; Volume: 20.146 m3; Weight: 48351.4 kg
Pours - Pour Comment: Updated based on latest DWG file recieved on 2nd march 2026; Pour Area: 145.4 m2; Pour Area PGZ: 57.7 m2; Pour Area NGZ: 58.6 m2; Pour Area PGX: 7.7 m2; Pour Area NXG: 5.9 m2; Pour Area PGY: 6.2 m2; Pour Area NGY: 6.4 m2; Pour Content Type: PART; Pour Material: Concrete_Undefined; Pour Top Level: +4.309; Pour Bottom Level: +2.670; Pour Volume: 20.146 m3; Pour Weight: 48351.4 kg; Pour Weight Net: 48351.4 kg; Pour Break Comment: Updated based on latest DWG file recieved on 2nd march 2026

# IfcBuildingElementProxy: _Is1ewljrn0-b_6b5almJBA_0, SVV Betong
In: Undefined
Description: _Is1ewljrn0-b_6b5almJBA_0; Material: CONCRETE/Concrete_Undefined
Tekla Common - Class: 26; Phase: 1; Top elevation: +9.153; Bottom elevation: +3.376
Tekla Quantity - Length: 37532.1 mm; Width: 33248.3 mm; Height: 5777.2 mm; Net surface area: 140.224 m2; Area per tons: 3.126 m2; Gross footprint area: 0 m2; Volume: 18.691 m3; Weight: 44858.9 kg
Pours - Pour Comment: WIP : railing; Pour Area: 140.2 m2; Pour Area PGZ: 16.3 m2; Pour Area NGZ: 23.1 m2; Pour Area PGX: 10.4 m2; Pour Area NXG: 10.2 m2; Pour Area PGY: 39.1 m2; Pour Area NGY: 37.2 m2; Pour Content Type: PART; Pour Material: Concrete_Undefined; Pour Top Level: +9.153; Pour Bottom Level: +3.376; Pour Volume: 18.691 m3; Pour Weight: 44858.9 kg; Pour Weight Net: 44858.9 kg; Pour Break Comment: WIP : railing

# IfcBuildingElementProxy: _pBKooncfsEqF1hXmlrRtSQ_2, CONCRETE ITEM
In: Undefined
Description: _pBKooncfsEqF1hXmlrRtSQ_2; Material: CONCRETE/Concrete_Undefined
Tekla Common - Class: 107; Phase: 1; Top elevation: +4.867; Bottom elevation: +3.129
Tekla Quantity - Length: 15601.7 mm; Width: 10687.5 mm; Height: 1738.3 mm; Net surface area: 116.288 m2; Area per tons: 0 m2; Gross footprint area: 0 m2; Volume: 0 m3; Weight: 0 kg
Pours - Pour Comment: updated edge beam; Pour Area: 116.3 m2; Pour Area PGZ: 0 m2; Pour Area NGZ: 0 m2; Pour Area PGX: 0 m2; Pour Area NXG: 0 m2; Pour Area PGY: 0 m2; Pour Area NGY: 0 m2; Pour Content Type: PART; Pour Material: Concrete_Undefined; Pour Top Level: +4.867; Pour Bottom Level: +3.129; Pour Volume: 0 m3; Pour Weight: 0 kg; Pour Weight Net: 0 kg; Pour Break Comment: updated edge beam

# IfcBuildingElementProxy: _pBKooncfsEqF1hXmlrRtSQ_3, CONCRETE ITEM
In: Undefined
Description: _pBKooncfsEqF1hXmlrRtSQ_3; Material: CONCRETE/Concrete_Undefined
Tekla Common - Class: 107; Phase: 1; Top elevation: +5.617; Bottom elevation: +3.317
Tekla Quantity - Length: 14248.1 mm; Width: 15765.6 mm; Height: 2299.6 mm; Net surface area: 123.833 m2; Area per tons: 2.998 m2; Gross footprint area: 0 m2; Volume: 17.211 m3; Weight: 41305.4 kg
Pours - Pour Comment: updated edge beam; Pour Area: 123.8 m2; Pour Area PGZ: 48.6 m2; Pour Area NGZ: 49.7 m2; Pour Area PGX: 10.6 m2; Pour Area NXG: 11.2 m2; Pour Area PGY: 0.9 m2; Pour Area NGY: 0.9 m2; Pour Content Type: PART; Pour Material: Concrete_Undefined; Pour Top Level: +5.617; Pour Bottom Level: +3.317; Pour Volume: 17.211 m3; Pour Weight: 41305.4 kg; Pour Weight Net: 41305.4 kg; Pour Break Comment: updated edge beam

# IfcColumn: HEA100 (61)
In: Undefined
Description: HEA100; Material: STEEL/S355J0
Tekla Common - Class: 512; Phase: 1
Tekla Quantity - Length: 1000.7 mm; Width: 100 mm; Height: 96 mm; Net surface area: 0.586 m2; Area per tons: 33.646 m2; Gross footprint area: 0.002 m2; Volume: 0.002 m3; Weight: 16.69 kg
ColumnBaseQuantities - Length: 1000.7 mm; OuterSurfaceArea: 0.6 m2; NetVolume: 0 m3; NetWeight: 15.7 kg
Pset_ColumnCommon - Slope: 1.5708 rad; IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation
87214000_bybrurekkver | +6.649 | +5.648
87214000_bybrurekkver | +6.530 | +5.530
87214000_bybrurekkver | +6.418 | +5.417
87214000_bybrurekkver | +6.305 | +5.305
87214000_bybrurekkver | +6.193 | +5.192
87214000_bybrurekkver | +6.080 | +5.080
87214000_bybrurekkver | +5.968 | +4.967
87214000_bybrurekkver | +5.855 | +4.855
87214000_bybrurekkver | +5.743 | +4.742
87214000_bybrurekkver | +5.636 | +4.636
87214000_bybrurekkver | +5.575 | +4.574
87214000_bybrurekkver | +5.514 | +4.513
87214000_bybrurekkver | +5.453 | +4.452
87214000_bybrurekkver | +5.392 | +4.391
87214000_bybrurekkver | +5.331 | +4.330
87214000_bybrurekkver | +5.270 | +4.269
87214000_bybrurekkver | +5.209 | +4.208
87214000_bybrurekkver | +5.148 | +4.147
87214000_bybrurekkver | +5.087 | +4.086
87214000_bybrurekkver | +5.026 | +4.025
87214000_bybrurekkver | +4.980 | +3.979
87214000_bybrurekkver | +4.976 | +3.976
87214000_bybrurekkver | +4.997 | +3.996
87214000_bybrurekkver | +5.004 | +4.003
87214000_bybrurekkver | +4.995 | +3.994
87214000_bybrurekkver | +4.970 | +3.969
87214000_bybrurekkver | +4.929 | +3.928
87214000_bybrurekkver | +4.883 | +3.882
2 x 87214000_bybrurekkver | +4.837 | +3.836
87214000_bybrurekkver | +4.782 | +3.781
87214000_bybrurekkver | +4.717 | +3.717
87214000_bybrurekkver | +4.643 | +3.642
87214000_bybrurekkver | +4.558 | +3.557
87214000_bybrurekkver | +4.469 | +3.468
87214000_bybrurekkver | +4.380 | +3.379
87214000_bybrurekkver | +4.662 | +3.662
87214000_bybrurekkver | +4.702 | +3.701
87214000_bybrurekkver | +4.764 | +3.764
87214000_bybrurekkver | +4.808 | +3.808
87214000_bybrurekkver | +4.830 | +3.830
87214000_bybrurekkver | +4.815 | +3.814
87214000_bybrurekkver | +4.816 | +3.815
87214000_bybrurekkver | +4.878 | +3.877
87214000_bybrurekkver | +4.937 | +3.936
87214000_bybrurekkver | +4.998 | +3.998
87214000_bybrurekkver | +5.060 | +4.060
87214000_bybrurekkver | +5.122 | +4.121
87214000_bybrurekkver | +5.184 | +4.183
87214000_bybrurekkver | +5.246 | +4.245
87214000_bybrurekkver | +5.308 | +4.307
87214000_bybrurekkver | +5.369 | +4.369
87214000_bybrurekkver | +5.430 | +4.429
87214000_bybrurekkver | +5.484 | +4.484
87214000_bybrurekkver | +5.547 | +4.546
87214000_bybrurekkver | +5.615 | +4.614
87214000_bybrurekkver | +5.690 | +4.690
87214000_bybrurekkver | +5.772 | +4.772
87214000_bybrurekkver | +5.862 | +4.861
87214000_bybrurekkver | +5.915 | +4.914
87214000_bybrurekkver | +5.813 | +4.813

# IfcColumn: HFCHS21.3*3.2 (989)
In: Undefined
Description: HFCHS21.3*3.2; Material: STEEL/Steel_Undefined
Tekla Common - Class: 3; Phase: 1
Tekla Quantity - Length: 900 mm; Width: 21.3 mm; Height: 21.3 mm; Net surface area: 0.06 m2; Area per tons: 48.996 m2; Gross footprint area: 0 m2; Volume: 0 m3; Weight: 1.29 kg
ColumnBaseQuantities - Length: 900 mm; OuterSurfaceArea: 0.1 m2; NetVolume: 0 m3; NetWeight: 1.2 kg
Pset_ColumnCommon - Slope: 1.5708 rad; IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation
BEAM | +6.643 | +5.743
BEAM | +6.637 | +5.737
BEAM | +6.631 | +5.731
BEAM | +6.625 | +5.725
BEAM | +6.619 | +5.719
BEAM | +6.612 | +5.712
BEAM | +6.606 | +5.706
BEAM | +6.600 | +5.700
BEAM | +6.594 | +5.694
BEAM | +6.587 | +5.687
BEAM | +6.581 | +5.681
BEAM | +6.575 | +5.675
BEAM | +6.569 | +5.669
BEAM | +6.563 | +5.663
BEAM | +6.556 | +5.656
BEAM | +6.550 | +5.650
BEAM | +6.544 | +5.644
BEAM | +6.538 | +5.638
BEAM | +6.525 | +5.625
BEAM | +6.519 | +5.619
BEAM | +6.513 | +5.613
BEAM | +6.506 | +5.606
BEAM | +6.500 | +5.600
BEAM | +6.494 | +5.594
BEAM | +6.488 | +5.588
BEAM | +6.481 | +5.581
BEAM | +6.475 | +5.575
BEAM | +6.469 | +5.569
BEAM | +6.463 | +5.563
BEAM | +6.456 | +5.556
BEAM | +6.450 | +5.550
BEAM | +6.444 | +5.544
BEAM | +6.438 | +5.538
BEAM | +6.432 | +5.532
BEAM | +6.425 | +5.525
BEAM | +6.413 | +5.513
BEAM | +6.406 | +5.506
BEAM | +6.400 | +5.500
BEAM | +6.394 | +5.494
BEAM | +6.388 | +5.488
BEAM | +6.381 | +5.481
BEAM | +6.375 | +5.475
BEAM | +6.369 | +5.469
BEAM | +6.363 | +5.463
BEAM | +6.356 | +5.456
BEAM | +6.350 | +5.450
BEAM | +6.344 | +5.444
BEAM | +6.338 | +5.438
BEAM | +6.332 | +5.432
BEAM | +6.325 | +5.425
BEAM | +6.319 | +5.419
BEAM | +6.313 | +5.413
BEAM | +6.300 | +5.400
BEAM | +6.294 | +5.394
BEAM | +6.288 | +5.388
BEAM | +6.281 | +5.381
BEAM | +6.275 | +5.375
BEAM | +6.269 | +5.369
BEAM | +6.263 | +5.363
BEAM | +6.256 | +5.356
BEAM | +6.250 | +5.350
BEAM | +6.244 | +5.344
BEAM | +6.238 | +5.338
BEAM | +6.231 | +5.331
BEAM | +6.225 | +5.325
BEAM | +6.219 | +5.319
BEAM | +6.213 | +5.313
BEAM | +6.207 | +5.307
BEAM | +6.200 | +5.300
BEAM | +6.188 | +5.288
BEAM | +6.181 | +5.281
BEAM | +6.175 | +5.275
BEAM | +6.169 | +5.269
BEAM | +6.163 | +5.263
BEAM | +6.156 | +5.256
BEAM | +6.150 | +5.250
BEAM | +6.144 | +5.244
BEAM | +6.138 | +5.238
BEAM | +6.131 | +5.231
BEAM | +6.125 | +5.225
BEAM | +6.119 | +5.219
BEAM | +6.113 | +5.213
BEAM | +6.106 | +5.206
BEAM | +6.100 | +5.200
BEAM | +6.094 | +5.194
BEAM | +6.088 | +5.188
BEAM | +6.075 | +5.175
BEAM | +6.069 | +5.169
BEAM | +6.063 | +5.163
BEAM | +6.056 | +5.156
BEAM | +6.050 | +5.150
BEAM | +6.044 | +5.144
BEAM | +6.038 | +5.138
BEAM | +6.031 | +5.131
BEAM | +6.025 | +5.125
BEAM | +6.019 | +5.119
BEAM | +6.013 | +5.113
BEAM | +6.007 | +5.107
BEAM | +6.000 | +5.100
BEAM | +5.994 | +5.094
BEAM | +5.988 | +5.088
BEAM | +5.982 | +5.082
BEAM | +5.975 | +5.075
BEAM | +5.963 | +5.063
BEAM | +5.956 | +5.056
BEAM | +5.950 | +5.050
BEAM | +5.944 | +5.044
BEAM | +5.938 | +5.038
BEAM | +5.931 | +5.031
BEAM | +5.925 | +5.025
BEAM | +5.919 | +5.019
2 x BEAM | +5.913 | +5.013
3 x BEAM | +5.906 | +5.006
2 x BEAM | +5.900 | +5.000
BEAM | +5.894 | +4.994
2 x BEAM | +5.888 | +4.988
2 x BEAM | +5.881 | +4.981
BEAM | +5.875 | +4.975
BEAM | +5.869 | +4.969
BEAM | +5.863 | +4.963
2 x BEAM | +5.850 | +4.950
BEAM | +5.844 | +4.944
BEAM | +5.838 | +4.938
2 x BEAM | +5.832 | +4.932
BEAM | +5.825 | +4.925
BEAM | +5.819 | +4.919
BEAM | +5.813 | +4.913
2 x BEAM | +5.807 | +4.907
BEAM | +5.801 | +4.901
BEAM | +5.795 | +4.895
2 x BEAM | +5.788 | +4.888
BEAM | +5.782 | +4.882
BEAM | +5.776 | +4.876
2 x BEAM | +5.769 | +4.869
BEAM | +5.763 | +4.863
BEAM | +5.757 | +4.857
2 x BEAM | +5.750 | +4.850
BEAM | +5.737 | +4.837
BEAM | +5.731 | +4.831
BEAM | +5.725 | +4.825
2 x BEAM | +5.718 | +4.818
BEAM | +5.712 | +4.812
2 x BEAM | +5.705 | +4.805
BEAM | +5.699 | +4.799
BEAM | +5.693 | +4.793
2 x BEAM | +5.687 | +4.787
BEAM | +5.681 | +4.781
BEAM | +5.675 | +4.775
BEAM | +5.669 | +4.769
BEAM | +5.663 | +4.763
BEAM | +5.658 | +4.758
BEAM | +5.652 | +4.752
BEAM | +5.647 | +4.747
BEAM | +5.642 | +4.742
BEAM | +5.633 | +4.733
BEAM | +5.629 | +4.729
2 x BEAM | +5.624 | +4.724
BEAM | +5.621 | +4.721
BEAM | +5.617 | +4.717
BEAM | +5.613 | +4.713
BEAM | +5.610 | +4.710
BEAM | +5.606 | +4.706
BEAM | +5.603 | +4.703
2 x BEAM | +5.600 | +4.700
BEAM | +5.597 | +4.697
BEAM | +5.594 | +4.694
BEAM | +5.591 | +4.691
BEAM | +5.588 | +4.688
2 x BEAM | +5.585 | +4.685
BEAM | +5.582 | +4.682
BEAM | +5.579 | +4.679
BEAM | +5.573 | +4.673
BEAM | +5.569 | +4.669
2 x BEAM | +5.566 | +4.666
BEAM | +5.563 | +4.663
BEAM | +5.560 | +4.660
BEAM | +5.556 | +4.656
BEAM | +5.553 | +4.653
BEAM | +5.550 | +4.650
BEAM | +5.546 | +4.646
BEAM | +5.543 | +4.643
BEAM | +5.539 | +4.639
BEAM | +5.536 | +4.636
BEAM | +5.532 | +4.632
2 x BEAM | +5.529 | +4.629
BEAM | +5.525 | +4.625
2 x BEAM | +5.522 | +4.622
BEAM | +5.518 | +4.618
BEAM | +5.511 | +4.611
2 x BEAM | +5.508 | +4.608
BEAM | +5.504 | +4.604
BEAM | +5.501 | +4.601
2 x BEAM | +5.498 | +4.598
BEAM | +5.494 | +4.594
BEAM | +5.491 | +4.591
BEAM | +5.487 | +4.587
BEAM | +5.484 | +4.584
BEAM | +5.481 | +4.581
BEAM | +5.477 | +4.577
BEAM | +5.474 | +4.574
BEAM | +5.471 | +4.571
2 x BEAM | +5.467 | +4.567
2 x BEAM | +5.464 | +4.564
2 x BEAM | +5.461 | +4.561
BEAM | +5.457 | +4.557
BEAM | +5.450 | +4.550
BEAM | +5.447 | +4.547
BEAM | +5.444 | +4.544
2 x BEAM | +5.440 | +4.540
2 x BEAM | +5.437 | +4.537
BEAM | +5.433 | +4.533
BEAM | +5.430 | +4.530
BEAM | +5.427 | +4.527
BEAM | +5.423 | +4.523
BEAM | +5.420 | +4.520
BEAM | +5.416 | +4.516
BEAM | +5.413 | +4.513
BEAM | +5.410 | +4.510
BEAM | +5.406 | +4.506
BEAM | +5.403 | +4.503
BEAM | +5.400 | +4.500
BEAM | +5.396 | +4.496
BEAM | +5.389 | +4.489
BEAM | +5.386 | +4.486
BEAM | +5.382 | +4.482
BEAM | +5.379 | +4.479
BEAM | +5.376 | +4.476
BEAM | +5.372 | +4.472
BEAM | +5.369 | +4.469
BEAM | +5.366 | +4.466
BEAM | +5.362 | +4.462
BEAM | +5.359 | +4.459
BEAM | +5.355 | +4.455
BEAM | +5.352 | +4.452
BEAM | +5.349 | +4.449
BEAM | +5.345 | +4.445
BEAM | +5.342 | +4.442
2 x BEAM | +5.339 | +4.439
BEAM | +5.335 | +4.435
BEAM | +5.328 | +4.428
BEAM | +5.325 | +4.425
BEAM | +5.321 | +4.421
BEAM | +5.318 | +4.418
BEAM | +5.315 | +4.415
BEAM | +5.311 | +4.411
BEAM | +5.308 | +4.408
2 x BEAM | +5.305 | +4.405
BEAM | +5.301 | +4.401
2 x BEAM | +5.298 | +4.398
BEAM | +5.294 | +4.394
2 x BEAM | +5.291 | +4.391
2 x BEAM | +5.288 | +4.388
BEAM | +5.284 | +4.384
2 x BEAM | +5.281 | +4.381
2 x BEAM | +5.278 | +4.378
2 x BEAM | +5.274 | +4.374
2 x BEAM | +5.267 | +4.367
2 x BEAM | +5.264 | +4.364
2 x BEAM | +5.261 | +4.361
2 x BEAM | +5.257 | +4.357
2 x BEAM | +5.254 | +4.354
2 x BEAM | +5.250 | +4.350
BEAM | +5.247 | +4.347
BEAM | +5.244 | +4.344
2 x BEAM | +5.240 | +4.340
BEAM | +5.237 | +4.337
BEAM | +5.234 | +4.334
2 x BEAM | +5.230 | +4.330
BEAM | +5.227 | +4.327
2 x BEAM | +5.223 | +4.323
BEAM | +5.220 | +4.320
BEAM | +5.217 | +4.317
BEAM | +5.213 | +4.313
2 x BEAM | +5.206 | +4.306
BEAM | +5.203 | +4.303
BEAM | +5.200 | +4.300
BEAM | +5.196 | +4.296
BEAM | +5.193 | +4.293
BEAM | +5.189 | +4.289
BEAM | +5.186 | +4.286
BEAM | +5.183 | +4.283
BEAM | +5.179 | +4.279
BEAM | +5.176 | +4.276
BEAM | +5.173 | +4.273
BEAM | +5.169 | +4.269
BEAM | +5.166 | +4.266
BEAM | +5.162 | +4.262
BEAM | +5.159 | +4.259
BEAM | +5.156 | +4.256
BEAM | +5.152 | +4.252
BEAM | +5.145 | +4.245
BEAM | +5.142 | +4.242
BEAM | +5.139 | +4.239
BEAM | +5.135 | +4.235
BEAM | +5.132 | +4.232
BEAM | +5.129 | +4.229
BEAM | +5.125 | +4.225
BEAM | +5.122 | +4.222
BEAM | +5.119 | +4.219
BEAM | +5.115 | +4.215
BEAM | +5.112 | +4.212
BEAM | +5.108 | +4.208
BEAM | +5.105 | +4.205
2 x BEAM | +5.102 | +4.202
BEAM | +5.098 | +4.198
BEAM | +5.095 | +4.195
BEAM | +5.091 | +4.191
2 x BEAM | +5.085 | +4.185
BEAM | +5.081 | +4.181
2 x BEAM | +5.078 | +4.178
BEAM | +5.074 | +4.174
BEAM | +5.071 | +4.171
BEAM | +5.067 | +4.167
BEAM | +5.064 | +4.164
BEAM | +5.061 | +4.161
BEAM | +5.057 | +4.157
2 x BEAM | +5.054 | +4.154
BEAM | +5.050 | +4.150
BEAM | +5.047 | +4.147
2 x BEAM | +5.044 | +4.144
BEAM | +5.040 | +4.140
2 x BEAM | +5.037 | +4.137
2 x BEAM | +5.034 | +4.134
2 x BEAM | +5.030 | +4.130
2 x BEAM | +5.024 | +4.124
BEAM | +5.021 | +4.121
BEAM | +5.018 | +4.118
BEAM | +5.014 | +4.114
BEAM | +5.011 | +4.111
BEAM | +5.008 | +4.108
2 x BEAM | +5.006 | +4.106
7 x BEAM | +5.003 | +4.103
5 x BEAM | +5.000 | +4.100
4 x BEAM | +4.997 | +4.097
3 x BEAM | +4.995 | +4.095
4 x BEAM | +4.993 | +4.093
3 x BEAM | +4.990 | +4.090
2 x BEAM | +4.988 | +4.088
3 x BEAM | +4.986 | +4.086
3 x BEAM | +4.984 | +4.084
BEAM | +4.983 | +4.083
2 x BEAM | +4.980 | +4.080
3 x BEAM | +4.978 | +4.078
2 x BEAM | +4.977 | +4.077
5 x BEAM | +4.976 | +4.076
4 x BEAM | +4.975 | +4.075
7 x BEAM | +4.974 | +4.074
3 x BEAM | +4.979 | +4.079
2 x BEAM | +4.981 | +4.081
3 x BEAM | +4.982 | +4.082
2 x BEAM | +4.985 | +4.085
2 x BEAM | +4.987 | +4.087
3 x BEAM | +4.989 | +4.089
BEAM | +4.991 | +4.091
2 x BEAM | +4.992 | +4.092
2 x BEAM | +4.996 | +4.096
2 x BEAM | +4.999 | +4.099
2 x BEAM | +5.001 | +4.101
4 x BEAM | +5.002 | +4.102
8 x BEAM | +5.004 | +4.104
6 x BEAM | +5.005 | +4.105
BEAM | +4.998 | +4.098
BEAM | +4.994 | +4.094
2 x BEAM | +4.972 | +4.072
2 x BEAM | +4.969 | +4.069
BEAM | +4.967 | +4.067
2 x BEAM | +4.965 | +4.065
BEAM | +4.963 | +4.063
BEAM | +4.960 | +4.060
BEAM | +4.958 | +4.058
BEAM | +4.956 | +4.056
BEAM | +4.954 | +4.054
BEAM | +4.951 | +4.051
BEAM | +4.949 | +4.049
BEAM | +4.947 | +4.047
BEAM | +4.944 | +4.044
BEAM | +4.942 | +4.042
BEAM | +4.940 | +4.040
BEAM | +4.937 | +4.037
BEAM | +4.935 | +4.035
BEAM | +4.932 | +4.032
2 x BEAM | +4.927 | +4.027
BEAM | +4.925 | +4.025
BEAM | +4.922 | +4.022
BEAM | +4.920 | +4.020
2 x BEAM | +4.917 | +4.017
BEAM | +4.915 | +4.015
BEAM | +4.912 | +4.012
2 x BEAM | +4.910 | +4.010
2 x BEAM | +4.907 | +4.007
2 x BEAM | +4.904 | +4.004
BEAM | +4.902 | +4.002
BEAM | +4.899 | +3.999
2 x BEAM | +4.897 | +3.997
2 x BEAM | +4.894 | +3.994
BEAM | +4.892 | +3.992
BEAM | +4.889 | +3.989
BEAM | +4.887 | +3.987
2 x BEAM | +4.882 | +3.982
BEAM | +4.879 | +3.979
BEAM | +4.877 | +3.977
BEAM | +4.874 | +3.974
BEAM | +4.872 | +3.972
BEAM | +4.869 | +3.969
BEAM | +4.867 | +3.967
BEAM | +4.864 | +3.964
BEAM | +4.861 | +3.961
BEAM | +4.859 | +3.959
2 x BEAM | +4.856 | +3.956
BEAM | +4.854 | +3.954
2 x BEAM | +4.851 | +3.951
BEAM | +4.848 | +3.948
BEAM | +4.846 | +3.946
2 x BEAM | +4.843 | +3.943
BEAM | +4.840 | +3.940
BEAM | +4.835 | +3.935
BEAM | +4.832 | +3.932
4 x BEAM | +4.829 | +3.929
4 x BEAM | +4.826 | +3.926
4 x BEAM | +4.823 | +3.923
4 x BEAM | +4.821 | +3.921
3 x BEAM | +4.818 | +3.918
5 x BEAM | +4.815 | +3.915
BEAM | +4.812 | +3.912
BEAM | +4.809 | +3.909
2 x BEAM | +4.805 | +3.905
BEAM | +4.802 | +3.902
2 x BEAM | +4.799 | +3.899
2 x BEAM | +4.796 | +3.896
BEAM | +4.793 | +3.893
BEAM | +4.790 | +3.890
BEAM | +4.786 | +3.886
BEAM | +4.780 | +3.880
BEAM | +4.776 | +3.876
BEAM | +4.773 | +3.873
BEAM | +4.769 | +3.869
BEAM | +4.766 | +3.866
BEAM | +4.763 | +3.863
2 x BEAM | +4.759 | +3.859
BEAM | +4.755 | +3.855
BEAM | +4.752 | +3.852
BEAM | +4.748 | +3.848
BEAM | +4.745 | +3.845
BEAM | +4.741 | +3.841
BEAM | +4.737 | +3.837
BEAM | +4.734 | +3.834
BEAM | +4.730 | +3.830
2 x BEAM | +4.726 | +3.826
2 x BEAM | +4.722 | +3.822
BEAM | +4.714 | +3.814
2 x BEAM | +4.711 | +3.811
2 x BEAM | +4.707 | +3.807
BEAM | +4.703 | +3.803
2 x BEAM | +4.699 | +3.799
2 x BEAM | +4.695 | +3.795
BEAM | +4.691 | +3.791
BEAM | +4.686 | +3.786
BEAM | +4.682 | +3.782
BEAM | +4.678 | +3.778
BEAM | +4.674 | +3.774
BEAM | +4.670 | +3.770
BEAM | +4.666 | +3.766
BEAM | +4.661 | +3.761
BEAM | +4.657 | +3.757
BEAM | +4.653 | +3.753
BEAM | +4.648 | +3.748
BEAM | +4.639 | +3.739
BEAM | +4.635 | +3.735
BEAM | +4.630 | +3.730
BEAM | +4.626 | +3.726
BEAM | +4.621 | +3.721
BEAM | +4.616 | +3.716
BEAM | +4.612 | +3.712
BEAM | +4.607 | +3.707
BEAM | +4.602 | +3.702
BEAM | +4.598 | +3.698
BEAM | +4.593 | +3.693
BEAM | +4.588 | +3.688
BEAM | +4.583 | +3.683
BEAM | +4.579 | +3.679
BEAM | +4.574 | +3.674
BEAM | +4.569 | +3.669
BEAM | +4.564 | +3.664
BEAM | +4.554 | +3.654
BEAM | +4.549 | +3.649
BEAM | +4.544 | +3.644
BEAM | +4.539 | +3.639
BEAM | +4.535 | +3.635
BEAM | +4.530 | +3.630
BEAM | +4.525 | +3.625
BEAM | +4.520 | +3.620
BEAM | +4.515 | +3.615
BEAM | +4.510 | +3.610
BEAM | +4.505 | +3.605
BEAM | +4.500 | +3.600
BEAM | +4.495 | +3.595
BEAM | +4.490 | +3.590
BEAM | +4.485 | +3.585
BEAM | +4.480 | +3.580
BEAM | +4.475 | +3.575
BEAM | +4.465 | +3.565
BEAM | +4.460 | +3.560
BEAM | +4.455 | +3.555
BEAM | +4.450 | +3.550
BEAM | +4.445 | +3.545
BEAM | +4.440 | +3.540
BEAM | +4.435 | +3.535
BEAM | +4.430 | +3.530
BEAM | +4.426 | +3.526
BEAM | +4.421 | +3.521
BEAM | +4.416 | +3.516
BEAM | +4.411 | +3.511
BEAM | +4.406 | +3.506
BEAM | +4.401 | +3.501
BEAM | +4.396 | +3.496
BEAM | +4.391 | +3.491
BEAM | +4.386 | +3.486
BEAM | +4.668 | +3.768
BEAM | +4.672 | +3.772
BEAM | +4.676 | +3.776
BEAM | +4.680 | +3.780
BEAM | +4.684 | +3.784
BEAM | +4.688 | +3.788
BEAM | +4.692 | +3.792
BEAM | +4.715 | +3.815
BEAM | +4.718 | +3.818
BEAM | +4.729 | +3.829
BEAM | +4.733 | +3.833
BEAM | +4.736 | +3.836
BEAM | +4.740 | +3.840
BEAM | +4.743 | +3.843
BEAM | +4.747 | +3.847
BEAM | +4.750 | +3.850
BEAM | +4.753 | +3.853
BEAM | +4.756 | +3.856
BEAM | +4.762 | +3.862
BEAM | +4.768 | +3.868
BEAM | +4.771 | +3.871
BEAM | +4.774 | +3.874
BEAM | +4.777 | +3.877
BEAM | +4.779 | +3.879
BEAM | +4.782 | +3.882
BEAM | +4.784 | +3.884
BEAM | +4.787 | +3.887
BEAM | +4.789 | +3.889
BEAM | +4.792 | +3.892
BEAM | +4.794 | +3.894
BEAM | +4.801 | +3.901
BEAM | +4.803 | +3.903
BEAM | +4.807 | +3.907
BEAM | +4.811 | +3.911
10 x BEAM | +4.813 | +3.913
3 x BEAM | +4.817 | +3.917
3 x BEAM | +4.819 | +3.919
3 x BEAM | +4.824 | +3.924
3 x BEAM | +4.827 | +3.927
2 x BEAM | +4.828 | +3.928
5 x BEAM | +4.830 | +3.930
5 x BEAM | +4.831 | +3.931
2 x BEAM | +4.822 | +3.922
2 x BEAM | +4.820 | +3.920
4 x BEAM | +4.814 | +3.914
BEAM | +4.816 | +3.916
BEAM | +4.825 | +3.925
BEAM | +4.833 | +3.933
BEAM | +4.834 | +3.934
BEAM | +4.836 | +3.936
BEAM | +4.839 | +3.939
BEAM | +4.841 | +3.941
BEAM | +4.845 | +3.945
BEAM | +4.847 | +3.947
BEAM | +4.849 | +3.949
BEAM | +4.853 | +3.953
BEAM | +4.858 | +3.958
BEAM | +4.860 | +3.960
BEAM | +4.863 | +3.963
BEAM | +4.865 | +3.965
BEAM | +4.868 | +3.968
BEAM | +4.870 | +3.970
BEAM | +4.873 | +3.973
BEAM | +4.876 | +3.976
BEAM | +4.885 | +3.985
BEAM | +4.888 | +3.988
BEAM | +4.891 | +3.991
BEAM | +4.901 | +4.001
BEAM | +4.914 | +4.014
BEAM | +4.921 | +4.021
BEAM | +4.924 | +4.024
BEAM | +4.931 | +4.031
BEAM | +4.934 | +4.034
BEAM | +4.941 | +4.041
BEAM | +4.945 | +4.045
BEAM | +4.948 | +4.048
BEAM | +4.952 | +4.052
BEAM | +4.955 | +4.055
BEAM | +4.959 | +4.059
BEAM | +4.962 | +4.062
BEAM | +5.010 | +4.110
BEAM | +5.013 | +4.113
BEAM | +5.017 | +4.117
BEAM | +5.020 | +4.120
BEAM | +5.027 | +4.127
BEAM | +5.041 | +4.141
BEAM | +5.048 | +4.148
BEAM | +5.051 | +4.151
BEAM | +5.058 | +4.158
BEAM | +5.065 | +4.165
BEAM | +5.068 | +4.168
BEAM | +5.072 | +4.172
BEAM | +5.075 | +4.175
BEAM | +5.082 | +4.182
BEAM | +5.089 | +4.189
BEAM | +5.092 | +4.192
BEAM | +5.096 | +4.196
BEAM | +5.099 | +4.199
BEAM | +5.106 | +4.206
BEAM | +5.109 | +4.209
BEAM | +5.113 | +4.213
BEAM | +5.116 | +4.216
BEAM | +5.120 | +4.220
BEAM | +5.127 | +4.227
BEAM | +5.130 | +4.230
BEAM | +5.133 | +4.233
BEAM | +5.137 | +4.237
BEAM | +5.140 | +4.240
BEAM | +5.144 | +4.244
BEAM | +5.147 | +4.247
BEAM | +5.151 | +4.251
BEAM | +5.154 | +4.254
BEAM | +5.157 | +4.257
BEAM | +5.161 | +4.261
BEAM | +5.164 | +4.264
BEAM | +5.168 | +4.268
BEAM | +5.171 | +4.271
BEAM | +5.175 | +4.275
BEAM | +5.178 | +4.278
BEAM | +5.181 | +4.281
BEAM | +5.188 | +4.288
BEAM | +5.192 | +4.292
BEAM | +5.195 | +4.295
BEAM | +5.199 | +4.299
BEAM | +5.202 | +4.302
