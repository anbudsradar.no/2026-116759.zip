Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcColumn: HFCHS21.3*3.2 (989)
Name | Top elevation | Bottom elevation
BEAM | +5.209 | +4.309
BEAM | +5.212 | +4.312
BEAM | +5.216 | +4.316
BEAM | +5.219 | +4.319
BEAM | +5.226 | +4.326
BEAM | +5.233 | +4.333
BEAM | +5.236 | +4.336
BEAM | +5.243 | +4.343
BEAM | +5.271 | +4.371
BEAM | +5.285 | +4.385
BEAM | +5.295 | +4.395
BEAM | +5.302 | +4.402
BEAM | +5.312 | +4.412
BEAM | +5.316 | +4.416
BEAM | +5.319 | +4.419
BEAM | +5.322 | +4.422
BEAM | +5.326 | +4.426
BEAM | +5.329 | +4.429
BEAM | +5.333 | +4.433
BEAM | +5.336 | +4.436
BEAM | +5.343 | +4.443
BEAM | +5.346 | +4.446
BEAM | +5.350 | +4.450
BEAM | +5.353 | +4.453
BEAM | +5.357 | +4.457
BEAM | +5.360 | +4.460
BEAM | +5.363 | +4.463
BEAM | +5.367 | +4.467
BEAM | +5.374 | +4.474
BEAM | +5.377 | +4.477
BEAM | +5.381 | +4.481
BEAM | +5.384 | +4.484
BEAM | +5.388 | +4.488
BEAM | +5.391 | +4.491
BEAM | +5.395 | +4.495
BEAM | +5.398 | +4.498
BEAM | +5.401 | +4.501
BEAM | +5.405 | +4.505
BEAM | +5.408 | +4.508
BEAM | +5.412 | +4.512
BEAM | +5.415 | +4.515
BEAM | +5.418 | +4.518
BEAM | +5.421 | +4.521
BEAM | +5.425 | +4.525
BEAM | +5.428 | +4.528
BEAM | +5.434 | +4.534
BEAM | +5.443 | +4.543
BEAM | +5.446 | +4.546
BEAM | +5.449 | +4.549
BEAM | +5.452 | +4.552
BEAM | +5.455 | +4.555
BEAM | +5.458 | +4.558
BEAM | +5.470 | +4.570
BEAM | +5.473 | +4.573
BEAM | +5.476 | +4.576
BEAM | +5.479 | +4.579
BEAM | +5.482 | +4.582
BEAM | +5.489 | +4.589
BEAM | +5.492 | +4.592
BEAM | +5.495 | +4.595
BEAM | +5.502 | +4.602
BEAM | +5.505 | +4.605
BEAM | +5.512 | +4.612
BEAM | +5.515 | +4.615
BEAM | +5.519 | +4.619
BEAM | +5.526 | +4.626
BEAM | +5.533 | +4.633
BEAM | +5.537 | +4.637
BEAM | +5.540 | +4.640
BEAM | +5.544 | +4.644
BEAM | +5.551 | +4.651
BEAM | +5.555 | +4.655
BEAM | +5.559 | +4.659
BEAM | +5.562 | +4.662
BEAM | +5.570 | +4.670
BEAM | +5.574 | +4.674
BEAM | +5.577 | +4.677
BEAM | +5.581 | +4.681
BEAM | +5.589 | +4.689
BEAM | +5.593 | +4.693
BEAM | +5.596 | +4.696
BEAM | +5.604 | +4.704
BEAM | +5.608 | +4.708
BEAM | +5.612 | +4.712
BEAM | +5.620 | +4.720
BEAM | +5.628 | +4.728
BEAM | +5.632 | +4.732
BEAM | +5.636 | +4.736
BEAM | +5.640 | +4.740
BEAM | +5.644 | +4.744
BEAM | +5.649 | +4.749
BEAM | +5.653 | +4.753
BEAM | +5.657 | +4.757
BEAM | +5.661 | +4.761
BEAM | +5.665 | +4.765
BEAM | +5.670 | +4.770
BEAM | +5.674 | +4.774
BEAM | +5.678 | +4.778
BEAM | +5.682 | +4.782
BEAM | +5.696 | +4.796
BEAM | +5.700 | +4.800
BEAM | +5.709 | +4.809
BEAM | +5.713 | +4.813
BEAM | +5.722 | +4.822
BEAM | +5.727 | +4.827
BEAM | +5.732 | +4.832
BEAM | +5.736 | +4.836
BEAM | +5.741 | +4.841
BEAM | +5.745 | +4.845
BEAM | +5.755 | +4.855
BEAM | +5.759 | +4.859
BEAM | +5.764 | +4.864
BEAM | +5.778 | +4.878
BEAM | +5.783 | +4.883
BEAM | +5.793 | +4.893
BEAM | +5.797 | +4.897
BEAM | +5.802 | +4.902
BEAM | +5.812 | +4.912
BEAM | +5.817 | +4.917
BEAM | +5.822 | +4.922
BEAM | +5.827 | +4.927
BEAM | +5.837 | +4.937
2 x BEAM | +5.842 | +4.942
BEAM | +5.847 | +4.947
BEAM | +5.852 | +4.952
BEAM | +5.858 | +4.958
BEAM | +5.868 | +4.968
2 x BEAM | +5.874 | +4.974
BEAM | +5.879 | +4.979
BEAM | +5.884 | +4.984
BEAM | +5.889 | +4.989
BEAM | +5.893 | +4.993
BEAM | +5.898 | +4.998
BEAM | +5.902 | +5.002
BEAM | +5.909 | +5.009
BEAM | +5.912 | +5.012
BEAM | +5.915 | +5.015
BEAM | +5.916 | +5.016
2 x BEAM | +5.917 | +5.017
BEAM | +5.910 | +5.010
BEAM | +5.895 | +4.995
BEAM | +5.867 | +4.967
BEAM | +5.859 | +4.959
BEAM | +5.833 | +4.933
BEAM | +5.824 | +4.924

# IfcColumn: RHS100*100*5 (26)
In: Undefined
Description: RHS100*100*5; Material: MISCELLANEOUS/Produktspesifikk
Tekla Common - Class: 512; Phase: 1
Tekla Quantity - Length: 200 mm; Width: 100 mm; Height: 100 mm; Net surface area: 0.082 m2; Area per tons: 0 m2; Gross footprint area: 0.002 m2; Volume: 0 m3; Weight: 0 kg
ColumnBaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.1 m2; NetVolume: 0 m3; NetWeight: 0 kg
Pset_ColumnCommon - Slope: 1.5708 rad; IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation
87214000_bybrurekkver | +4.145 | +3.945
87214000_bybrurekkver | +4.184 | +3.984
87214000_bybrurekkver | +4.247 | +4.047
87214000_bybrurekkver | +4.291 | +4.091
87214000_bybrurekkver | +4.313 | +4.113
87214000_bybrurekkver | +4.297 | +4.097
87214000_bybrurekkver | +4.298 | +4.098
87214000_bybrurekkver | +4.319 | +4.119
87214000_bybrurekkver | +4.360 | +4.160
87214000_bybrurekkver | +4.419 | +4.219
87214000_bybrurekkver | +4.481 | +4.281
87214000_bybrurekkver | +4.543 | +4.343
87214000_bybrurekkver | +4.604 | +4.404
87214000_bybrurekkver | +4.666 | +4.466
87214000_bybrurekkver | +4.728 | +4.528
87214000_bybrurekkver | +4.790 | +4.590
87214000_bybrurekkver | +4.852 | +4.652
87214000_bybrurekkver | +4.912 | +4.712
87214000_bybrurekkver | +4.967 | +4.767
87214000_bybrurekkver | +5.029 | +4.829
87214000_bybrurekkver | +5.097 | +4.897
87214000_bybrurekkver | +5.173 | +4.973
87214000_bybrurekkver | +5.255 | +5.055
87214000_bybrurekkver | +5.344 | +5.144
87214000_bybrurekkver | +5.397 | +5.197
87214000_bybrurekkver | +5.296 | +5.096

# IfcColumn: SIGMA (10)
In: Undefined
Description: SIGMA; Material: STEEL/S355J0
Tekla Common - Class: 512; Phase: 1
Tekla Quantity - Length: 481.4 mm; Width: 100 mm; Height: 55 mm; Net surface area: 0.233 m2; Area per tons: 0 m2; Gross footprint area: 0.001 m2; Volume: 0 m3; Weight: 3.68 kg
ColumnBaseQuantities - Length: 481.4 mm; OuterSurfaceArea: 0 m2; NetVolume: 0 m3; NetWeight: 3.7 kg
Pset_ColumnCommon - Slope: 1.5708 rad; IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation
87214000_bybrurekkver | +3.510 | +3.028
87214000_bybrurekkver | +3.586 | +3.104
87214000_bybrurekkver | +3.662 | +3.180
87214000_bybrurekkver | +3.737 | +3.256
87214000_bybrurekkver | +3.812 | +3.330
87214000_bybrurekkver | +3.882 | +3.400
87214000_bybrurekkver | +3.946 | +3.465
87214000_bybrurekkver | +4.006 | +3.525
87214000_bybrurekkver | +4.061 | +3.580
87214000_bybrurekkver | +4.112 | +3.631

# IfcPlate: PL10*200 (71)
In: Undefined
Description: PL10*200; Material: STEEL/S235JR
Tekla Common - Class: 520; Phase: 1
Tekla Quantity - Length: 200 mm; Width: 10 mm; Height: 200 mm; Net surface area: 0.076 m2; Area per tons: 31.132 m2; Gross footprint area: 0.031 m2; Volume: 0 m3; Weight: 2.43 kg
PlateBaseQuantities - Width: 200 mm; NetArea: 0.1 m2; GrossArea: 0 m2; CrossSectionArea: 0 m2; NetVolume: 0 m3; GrossVolume: 0 m3
Pset_PlateCommon - IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation
84861000_boltegruppe | +5.264 | +5.254
84861000_boltegruppe | +5.146 | +5.136
84861000_boltegruppe | +5.033 | +5.023
84861000_boltegruppe | +4.921 | +4.911
84861000_boltegruppe | +4.808 | +4.798
84861000_boltegruppe | +4.696 | +4.686
84861000_boltegruppe | +4.583 | +4.573
84861000_boltegruppe | +4.471 | +4.461
84861000_boltegruppe | +4.358 | +4.348
84861000_boltegruppe | +4.252 | +4.242
84861000_boltegruppe | +4.190 | +4.180
84861000_boltegruppe | +4.129 | +4.119
84861000_boltegruppe | +4.068 | +4.058
84861000_boltegruppe | +4.007 | +3.997
84861000_boltegruppe | +3.946 | +3.936
84861000_boltegruppe | +3.885 | +3.875
84861000_boltegruppe | +3.824 | +3.814
84861000_boltegruppe | +3.763 | +3.753
84861000_boltegruppe | +3.702 | +3.692
84861000_boltegruppe | +3.641 | +3.631
84861000_boltegruppe | +3.595 | +3.585
84861000_boltegruppe | +3.592 | +3.582
84861000_boltegruppe | +3.612 | +3.602
84861000_boltegruppe | +3.619 | +3.609
84861000_boltegruppe | +3.610 | +3.600
84861000_boltegruppe | +3.585 | +3.575
84861000_boltegruppe | +3.544 | +3.534
84861000_boltegruppe | +3.499 | +3.489
2 x 84861000_boltegruppe | +3.452 | +3.442
84861000_boltegruppe | +3.397 | +3.387
84861000_boltegruppe | +3.333 | +3.323
84861000_boltegruppe | +3.258 | +3.248
84861000_boltegruppe | +3.174 | +3.164
84861000_boltegruppe | +3.084 | +3.074
84861000_boltegruppe | +2.995 | +2.985
84861000_boltegruppe | +2.644 | +2.634
84861000_boltegruppe | +2.720 | +2.710
84861000_boltegruppe | +2.796 | +2.786
84861000_boltegruppe | +2.872 | +2.862
84861000_boltegruppe | +2.946 | +2.936
84861000_boltegruppe | +3.016 | +3.006
84861000_boltegruppe | +3.081 | +3.071
84861000_boltegruppe | +3.141 | +3.131
84861000_boltegruppe | +3.196 | +3.186
84861000_boltegruppe | +3.247 | +3.237
84861000_boltegruppe | +3.278 | +3.268
84861000_boltegruppe | +3.317 | +3.307
84861000_boltegruppe | +3.380 | +3.370
84861000_boltegruppe | +3.424 | +3.414
84861000_boltegruppe | +3.446 | +3.436
84861000_boltegruppe | +3.430 | +3.420
84861000_boltegruppe | +3.431 | +3.421
84861000_boltegruppe | +3.493 | +3.483
84861000_boltegruppe | +3.552 | +3.542
84861000_boltegruppe | +3.614 | +3.604
84861000_boltegruppe | +3.676 | +3.666
84861000_boltegruppe | +3.737 | +3.727
84861000_boltegruppe | +3.799 | +3.789
84861000_boltegruppe | +3.861 | +3.851
84861000_boltegruppe | +3.923 | +3.913
84861000_boltegruppe | +3.985 | +3.975
84861000_boltegruppe | +4.045 | +4.035
84861000_boltegruppe | +4.100 | +4.090
84861000_boltegruppe | +4.162 | +4.152
84861000_boltegruppe | +4.230 | +4.220
84861000_boltegruppe | +4.306 | +4.296
84861000_boltegruppe | +4.388 | +4.378
84861000_boltegruppe | +4.477 | +4.467
84861000_boltegruppe | +4.530 | +4.520
84861000_boltegruppe | +4.429 | +4.419

# IfcPlate: PL25*200 (71)
In: Undefined
Description: PL25*200; Material: MISCELLANEOUS/Produktspesifikk
Tekla Common - Class: 512; Phase: 1
Tekla Quantity - Length: 200 mm; Width: 25 mm; Height: 200 mm; Net surface area: 0.103 m2; Area per tons: 0 m2; Gross footprint area: 0.038 m2; Volume: 0.001 m3; Weight: 0 kg
PlateBaseQuantities - Width: 200 mm; NetArea: 0.1 m2; GrossArea: 0 m2; CrossSectionArea: 0 m2; NetVolume: 0 m3; GrossVolume: 0 m3
Pset_PlateCommon - IsExternal: no; LoadBearing: no
Name | Top elevation | Bottom elevation
87214000_bybrurekkver | +5.648 | +5.623
87214000_bybrurekkver | +5.530 | +5.505
87214000_bybrurekkver | +5.417 | +5.392
87214000_bybrurekkver | +5.305 | +5.280
87214000_bybrurekkver | +5.192 | +5.167
87214000_bybrurekkver | +5.080 | +5.055
87214000_bybrurekkver | +4.967 | +4.942
87214000_bybrurekkver | +4.855 | +4.830
87214000_bybrurekkver | +4.742 | +4.717
87214000_bybrurekkver | +4.636 | +4.611
87214000_bybrurekkver | +4.574 | +4.549
87214000_bybrurekkver | +4.513 | +4.488
87214000_bybrurekkver | +4.452 | +4.427
87214000_bybrurekkver | +4.391 | +4.366
87214000_bybrurekkver | +4.330 | +4.305
87214000_bybrurekkver | +4.269 | +4.244
87214000_bybrurekkver | +4.208 | +4.183
87214000_bybrurekkver | +4.147 | +4.122
87214000_bybrurekkver | +4.086 | +4.061
87214000_bybrurekkver | +4.025 | +4.000
87214000_bybrurekkver | +3.979 | +3.954
87214000_bybrurekkver | +3.976 | +3.951
87214000_bybrurekkver | +3.996 | +3.971
87214000_bybrurekkver | +4.003 | +3.978
87214000_bybrurekkver | +3.994 | +3.969
87214000_bybrurekkver | +3.969 | +3.944
87214000_bybrurekkver | +3.928 | +3.903
87214000_bybrurekkver | +3.882 | +3.857
2 x 87214000_bybrurekkver | +3.836 | +3.811
87214000_bybrurekkver | +3.781 | +3.756
87214000_bybrurekkver | +3.717 | +3.692
87214000_bybrurekkver | +3.642 | +3.617
87214000_bybrurekkver | +3.557 | +3.532
87214000_bybrurekkver | +3.468 | +3.443
87214000_bybrurekkver | +3.379 | +3.354
87214000_bybrurekkver | +3.028 | +3.003
87214000_bybrurekkver | +3.104 | +3.079
87214000_bybrurekkver | +3.180 | +3.155
87214000_bybrurekkver | +3.256 | +3.231
87214000_bybrurekkver | +3.330 | +3.305
87214000_bybrurekkver | +3.400 | +3.375
87214000_bybrurekkver | +3.465 | +3.440
87214000_bybrurekkver | +3.525 | +3.500
87214000_bybrurekkver | +3.580 | +3.555
87214000_bybrurekkver | +3.631 | +3.606
87214000_bybrurekkver | +3.662 | +3.637
87214000_bybrurekkver | +3.701 | +3.676
87214000_bybrurekkver | +3.764 | +3.739
87214000_bybrurekkver | +3.808 | +3.783
87214000_bybrurekkver | +3.830 | +3.805
87214000_bybrurekkver | +3.814 | +3.789
87214000_bybrurekkver | +3.815 | +3.790
87214000_bybrurekkver | +3.877 | +3.852
87214000_bybrurekkver | +3.936 | +3.911
87214000_bybrurekkver | +3.998 | +3.973
87214000_bybrurekkver | +4.060 | +4.035
87214000_bybrurekkver | +4.121 | +4.096
87214000_bybrurekkver | +4.183 | +4.158
87214000_bybrurekkver | +4.245 | +4.220
87214000_bybrurekkver | +4.307 | +4.282
87214000_bybrurekkver | +4.369 | +4.344
87214000_bybrurekkver | +4.429 | +4.404
87214000_bybrurekkver | +4.484 | +4.459
87214000_bybrurekkver | +4.546 | +4.521
87214000_bybrurekkver | +4.614 | +4.589
87214000_bybrurekkver | +4.690 | +4.665
87214000_bybrurekkver | +4.772 | +4.747
87214000_bybrurekkver | +4.861 | +4.836
87214000_bybrurekkver | +4.914 | +4.889
87214000_bybrurekkver | +4.813 | +4.788
